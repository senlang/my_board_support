## linux-3.5/drivers/char/tiny4412_leds_demo/Kconfig
```kconfig
config LED_DEMO
	tristate "Android Led Demo"
	default n
	help
	This is the led demo for Android system.
```
